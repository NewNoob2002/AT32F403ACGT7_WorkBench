# Keil uVision project AT32F403ACGT7_WorkBench.uvprojx, settings and files
target AT32F403ACGT7_WorkBench (6240000::V6.24::.\ARMCLANG6_22)
  device: -AT32F403ACGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.0.9
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32F403ACGT7_WorkBench +hex
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: AT32F403ACGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1,__CORE_DEBUG
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\..\Arduino;..\..\platform;..\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: main.cpp at32f403a_407_wk_config.c at32f403a_407_int.c wk_system.c wk_debug.c
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group cmsis
    ./: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group platform/core
    ../../platform/core/: extend_SRAM.c
  group Arduino
    ../../Arduino/: itoa.c delay.c yield.c abi.cpp Print.cpp Stream.cpp WMath.cpp WString.cpp
    ../../Arduino/variants/at32f403a_xx/: variant.cpp
  group Arduino/avr
    ../../Arduino/avr/: dtostrf.c
  group Arduino/drivers
    ../../Arduino/drivers/gpio/: gpio.cpp
    ../../Arduino/drivers/usart/: usart.cpp usart_config.cpp
    ../../Arduino/drivers/adc/: adc.cpp adc_config.cpp
